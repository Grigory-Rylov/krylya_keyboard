## config/boards/shields/krylya_keyboard/Kconfig.shield
```kconfig
config SHIELD_KRYLYA_KEYBOARD
    def_bool $(shields_list_contains,krylya_keyboard)
```
